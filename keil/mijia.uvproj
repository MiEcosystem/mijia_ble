# Keil uVision project mijia.uvproj, settings and files
target cst92f30 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: CST92F30 Chipsea
  cpu: IRAM(0x20010000-0x200127FF) IROM(0x1FFF4000-0x2000FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: cst92f30
  AfterMake: fromelf.exe --bin -o  .\Bin\cst92f30.bin  .\Objects\cst92f30.axf
  AfterMake: fromelf.exe .\Objects\cst92f30.axf --i32combined --output .\Bin\cst92f30.hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\components\ble\controller;..\..\..\..\components\ble\hci;..\..\..\..\components\ble\host;..\..\..\..\components\ble\include;..\..\..\..\components\cmsis\device;..\..\..\..\components\cmsis\include;..\..\..\..\components\driver;..\..\..\..\components\inc;..\..\..\..\components\osal\include;..\..\..\..\components\profiles\DevInfo;..\..\..\..\components\profiles\GATT;..\..\..\..\components\profiles\Roles;..\..\..\..\components\profiles\MijiaProfile;..\..\..\..\libraries;..\src;..\..\..\..\external\cs_printf;..\src\mijia_libs\common;..\src\mijia_libs\mible_app_authen;..\src\mijia_portable
  library: MicroLIB
  memory RVCT4: ROM 0x1fff4000 size 0x1c000
  memory RVCT9: RAM 0x20010000 size 0x2800
  scatter file: ..\..\..\..\link\keil\cst92f30_link.sct
  link misc: ..\..\..\..\link\keil\rom_addr.txt
  group cmsis
    ../../../../components/cmsis/device/keil/: startup_cst92f30.s
    ../../../../components/cmsis/device/: system_cst92f30.c
  group driver
    ../../../../components/driver/: pwrmgr.c common.c gpio.c uart.c flash.c rcc.c
  group osal
    ../../../../components/osal/snv/: osal_snv.c
  group profiles
    ../../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../../components/profiles/GATT/: gattservapp.c
    ../../../../components/profiles/Roles/: gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../../../../components/profiles/MijiaProfile/: mijiaService.c
  group libraries
    ../../../../libraries/keil/: cst92f30_btlib.lib
  group app
    ../src/: main.c cst92f30_it.c board.c OSAL_MijiaPeripheral.c MijiaPeripheral.c MijiaPeripheral_Main.c
  group cs_printf
    ../../../../external/cs_printf/: cs_printf.c
  group mijia_libs
    ../src/mijia_libs/common/: ccm.c mible_beacon.c queue.c sha256_hkdf.c
    ../src/mijia_libs/mible_app_authen/: mible_app_authen.lib
  group mijia_portable
    ../src/mijia_portable/: mible_api.c aes.c chipsea_api.c chipsea_func.c chipsea_fifo.c
