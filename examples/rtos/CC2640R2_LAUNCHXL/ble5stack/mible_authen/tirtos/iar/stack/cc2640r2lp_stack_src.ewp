# IAR project cc2640r2lp_stack_src.ewp, settings and files
configuration FlashOnly_Library (ARM, debug)
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DeviceFamily_CC26X2
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt; --aeabi; -f $SRC_BLE_DIR$\config\build_components.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config_src.opt; --diag_suppress=Pa050; -Dxdc_target_types__=iar\targets\arm\std.h
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\npi\stack; $SRC_BLE_DIR$\hal\src\target\_common; $EXAMPLE_BLE_ROOT$\src\stack; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\npi\src; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SRC_BLE_DIR$\services\src\saddr; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\rf_patches; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $XDCROOT$\packages
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  ILINK.IlinkOutputFile: ble5_simple_peripheral_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: FLASH_ONLY_BUILD=2; CC2650=2
  ILINK.IlinkProgramEntryLabel: startup_entry
  group HAL/API
    $SRC_BLE_DIR$/hal/src/target/_common/: crypto_api.h ecc_api.h rf_api.h rtos_drivers.h trng_api.h
  group HAL/Common
    $SRC_BLE_DIR$/hal/src/common/: hal_assert.c
  group HAL/Include
    $SRC_BLE_DIR$/hal/src/inc/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2650/_common
    $SRC_BLE_DIR$/hal/src/target/_common/: hal_mcu.h
    $SRC_BLE_DIR$/hal/src/target/_common/cc26xx/: mb.h rf_hal.h
  group HAL/Target/CC2650/Config
    $SRC_BLE_DIR$/hal/src/target/_common/: hal_board_cfg.h
  group HAL/Target/CC2650/Drivers
    $SRC_BLE_DIR$/hal/src/target/_common/: hal_flash_wrapper.c hal_rtc_wrapper.h hal_trng_wrapper.c hal_trng_wrapper.h
  group HCI
    $SRC_BLE_DIR$/hci/cc26xx/: hci.c hci_data.c hci_event.c
    $SRC_BLE_DIR$/inc/: hci.h
  group HCI_TL
    $SRC_BLE_DIR$/hci/cc26xx/: hci_tl.c
    $SRC_BLE_DIR$/inc/: hci_tl.h
  group Host
    $SRC_BLE_DIR$/inc/: att.h att_internal.h gap.h gap_internal.h gapbondmgr.h gapgattserver.h gatt.h gatt_internal.h gatt_uuid.h gattservapp.h l2cap.h l2cap_internal.h linkdb.h sm.h sm_internal.h smp.h
    $SRC_BLE_DIR$/host/: att_client.c att_server.c att_util.c gap.c gap_advertiser.c gap_configmgr.c gap_devmgr.c gap_linkmgr.c gap_perilinkmgr.c gap_task.c gapbondmgr.c gapgattserver.c gatt_client.c gatt_server.c gatt_task.c gatt_uuid.c gattservapp.c gattservapp_util.c l2cap_if.c l2cap_task.c l2cap_util.c linkdb.c sm_ecc.c sm_intpairing.c sm_mgr.c sm_pairing.c sm_rsppairing.c sm_task.c smp.c
  group ICallBLE
    $SRC_BLE_DIR$/icall/inc/: ble_dispatch.h
    $SRC_BLE_DIR$/icall/stack/: ble_dispatch_JT.c ble_dispatch_lite.c
    $SRC_BLE_DIR$/icall/src/: icall_lite_translation.c
  group LL
    $SRC_BLE_DIR$/controller/cc26xx/ll/: ble.c ll.c ll_access_address.c ll_adv_end_causes.c ll_ae.c ll_common.c ll_data.c ll_ecc.c ll_enc.c ll_error_end_causes.c ll_init_end_causes.c ll_isr.c ll_master_end_causes.c ll_privacy.c ll_rat.c ll_scan_end_causes.c ll_scheduler.c ll_slave_end_causes.c ll_timer_drift.c ll_wl.c
  group LL/Include
    $SRC_BLE_DIR$/controller/cc26xx/inc/: ble.h ble_isr.h ll.h ll_common.h ll_ecc.h ll_enc.h ll_privacy.h ll_rat.h ll_scheduler.h ll_test_mode.h ll_timer_drift.h ll_wl.h
  group LL_CONFIG
    $SRC_BLE_DIR$/controller/cc26xx/ll/: ll_config.c
    $SRC_BLE_DIR$/controller/cc26xx/inc/: ll_config.h ll_user_config.h
  group NPI
    $SRC_BLE_DIR$/common/cc26xx/npi/stack/: npi.c
  group OSAL
    $SRC_BLE_DIR$/osal/src/inc/: comdef.h osal.h osal_bufmgr.h osal_cbtimer.h osal_clock.h osal_list.h osal_memory.h osal_pwrmgr.h osal_snv.h osal_task.h osal_timers.h
    $SRC_BLE_DIR$/osal/src/common/: osal.c osal_bufmgr.c osal_cbtimer.c osal_clock.c osal_list.c osal_memory_icall.c osal_pwrmgr.c osal_timers.c
    $SRC_BLE_DIR$/osal/src/mcu/cc26xx/: osal_snv_wrapper.c
  group Startup
    $SRC_BLE_DIR$/icall/stack/: ble_user_config.c
    $SRC_BLE_DIR$/common/cc26xx/: icall_startup.c
    $EXAMPLE_BLE_ROOT$/src/stack/: osal_icall_ble.c
  group Tools
    $SRC_BLE_DIR$/config/: build_components.opt
    ../../: build_config_src.opt
    $SRC_BLE_DIR$/common/cc26xx/: onboard.c onboard.h
  group Tools/defines
    defines/: cc26x2r1lp_stack_src_FlashOnly_Library.opt
