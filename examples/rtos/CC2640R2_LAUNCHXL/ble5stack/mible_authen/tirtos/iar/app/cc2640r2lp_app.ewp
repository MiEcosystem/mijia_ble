# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM_StackLibrary (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DeviceFamily_CC26X0R2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt; -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; -f ..\config\configPkg\compiler.opt.defs; --no_path_in_file_macros
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $EXAMPLE_BLE_ROOT$\src\; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_COMMON_DIR$\..\; $SRC_MIBLE_DIR$; $SRC_MIBLE_DIR$\extra\uartlog\; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\profiles\simple_profile\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$; $SRC_BLE_DIR$\common\cc26xx\kernel\cc2640\config; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source; $SRC_MIBLE_DIR$\libs\common; $SRC_MIBLE_DIR$\libs\mible_app_authen; $SRC_MIBLE_DIR$\portable
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0 -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\app_ble.cfg
  ILINK.IlinkOutputFile: ble5_mible_test_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2; CACHE_AS_RAM=1
  ILINK.IlinkIcfFile: cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\iar\m3\grlib.a; $SRC_MIBLE_DIR$\libs\mijia_std_authen_IAR_CC2640R2_1_1_4_752fc700.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../src/app/: mible_application.c mible_task.c mible_task.h
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/: util.c
  group Drivers
    ../../../../../../../../source/ti/ble5stack/hal/src/target/_common/: hal_flash_wrapper.c
  group Drivers/ECC
    ../../../../../../../../source/ti/ble5stack/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    ../../../../../../../../source/ti/ble5stack/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    ../../../../../../../../source/ti/ble5stack/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    ../../../../../../../../source/ti/ble5stack/icall/src/inc/: icall.h
    ../../../../../../../../source/ti/ble5stack/icall/inc/: icall_addrs.h
  group ICallBLE
    ../../../../../../../../source/ti/ble5stack/icall/app/: ble_user_config.c icall_api_lite.c
    ../../../../../../../../source/ti/ble5stack/icall/inc/: ble_user_config.h icall_ble_apimsg.h
  group Include
    ../../../../../../../../source/ti/ble5stack/inc/: gap.h gapbondmgr.h gapgattserver.h gatt.h hci.h
    ../../../../../../../../source/ti/ble5stack/osal/src/inc/: osal_snv.h
  group MiBLE
    ../../../../../../../../source/ti/ble5stack/mible/portable/: cc26xx_api.c cc26xx_api.h mible_api.c mible_api.h mible_log.h mible_log_internal.h mible_port.h mible_type.h
    ../../../../../../../../source/ti/ble5stack/mible/libs/common/: ccm.c mible_beacon.c queue.c
    ../../../../../../../../source/ti/ble5stack/mible/extra/uartlog/: UartLog.c UartLog.h
  group Profiles
    ../../../../../../../../source/ti/ble5stack/profiles/dev_info/cc26xx/: devinfoservice.c
    ../../../../../../../../source/ti/ble5stack/profiles/dev_info/: devinfoservice.h
    ../../../../../../../../source/ti/ble5stack/inc/: gatt_profile_uuid.h gatt_uuid.h
    ../../../../../../../../source/ti/ble5stack/host/: gatt_uuid.c gattservapp_util.c
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    ../../../../../../../../source/ti/ble5stack/target/: board.c
    ../../../src/: ccfg_app_ble.c
    ../../../src/app/: main.c
  group Tools
    ../../: app_ble.cfg
    defines/: cc2640r2lp_app_FlashROM_StackLibrary.opt
    ./: cc26xx_app_and_stack.icf
