# Keil uVision project mijia_profile_server_bm.uvprojx, settings and files
target mijia_profile_server_bm Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: QN9080C NXP
  pack: NXP.QN908x_DFP.1.1.4
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: mijia_profile_server_bm.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_QN908X, SDK_DEBUGCONSOLE=1, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, CFG_BLE_PRJ=1, CPU_QN9080C MI_LOG_ENABLED
  c misc: --preinclude ../../bm/app_preinclude.h 
--diag_suppress=1,94 
--diag_suppress=66,1296,186  
--library_interface=armcc  
--library_type=standardlib  
--no_wchar
  c include: ../../../../../../../../../../../CMSIS/Include;../../../../../../../../../../../devices;../../../../../../../../../../../middleware/wireless/framework_5.6.3/OSAbstraction/Interface;..;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Flash/Internal;../../../../../../../../../../../middleware/wireless/framework_5.6.3/GPIO;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Keyboard/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/LED/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Common;../../../../../../../../../../../middleware/wireless/framework_5.6.3/MemManager/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Messaging/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Panic/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/RNG/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/NVM/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/NVM/Source;../../../../../../../../../../../middleware/wireless/framework_5.6.3/SerialManager/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/SerialManager/Source;../../../../../../../../../../../middleware/wireless/framework_5.6.3/SerialManager/Source/SPI_Adapter;../../../../../../../../../../../middleware/wireless/framework_5.6.3/TimersManager/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/TimersManager/Source;../../../../../../../../../../../middleware/wireless/framework_5.6.3/ModuleInfo;../../../../../../../../../../../middleware/wireless/framework_5.6.3/FunctionLib;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Lists;../../../../../../../../../../../middleware/wireless/framework_5.6.3/SecLib;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Shell/Interface;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/host/interface;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/host/config;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/application/common;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/controller/interface;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/controller/interface/qn908xcdk;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/hci_transport/interface;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/application/common/gatt_db;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/application/common/gatt_db/macros;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/profiles/battery;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/profiles/device_info;../../../../../../../../../../../middleware/wireless/framework_5.6.3/MWSCoexistence/Interface;../..;../../../../../../../../../../../devices/QN908XC/drivers;../../../../../../../../../../../devices/QN908XC/utilities;../../../../../../../../../../../devices/QN908XC;../../../../portable;../../../../../../libs/common;../../../../../../libs/mible_app_authen;..\..\..\..\..\..\..\..\..\..\..\middleware\wireless\framework_5.6.3\Common\devices\QN908XC
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x4000400 size 0xfc00
  scatter file: QN908XC_connectivity.scf
  link misc: ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/host/lib/lib_ble_5-0_host_peripheral_cm4.a 
../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/controller/lib/lib_ble_QN908XC_controller.a 
../../../../../../../../../../../middleware/wireless/framework_5.6.3/SecLib/lib_crypto_m4.a 
--remove 
--symdefs 
= 
../../../../../../../../../../../middleware/wireless/framework_5.6.3/Common/devices/QN908XC/mdk/fw_symbols_mdk.h 
--predefine="-DgUseNVMLink_d=1" 
--predefine="-DgEraseNVMLink_d=1" 
--predefine="-D__ram_vector_table__=1" 
--predefine="-DNV_STORAGE_MAX_SECTORS=4" 
--keep=*.o(NVM_TABLE) 
--datacompressor=off
  group board
    ../: board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h clock_config.c clock_config.h nvds.h
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Common/devices/QN908XC/mdk/: fw_symbols_mdk.h
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Common/devices/QN908XC/: rco32k_calibration.c rco32k_calibration.h
  group startup
    ../../../../../../../../../../../devices/QN908XC/arm/: startup_QN908XC.s
    ../../../../../../../../../../../devices/QN908XC/: system_QN908XC.c system_QN908XC.h
  group framework-OSAbstraction-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/OSAbstraction/Interface/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group framework-OSAbstraction-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/OSAbstraction/Source/: fsl_os_abstraction_bm.c
  group source
    ../: app_preinclude.h
    ../../: app_config.c gatt_db.h gatt_uuid128.h mijia_profile_server.c mijia_profile_server.h
  group framework-Flash-Internal
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Flash/Internal/: Flash_Adapter.h Flash_Adapter.c
  group framework-GPIO-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/GPIO/: GPIO_Adapter.h
  group framework-GPIO-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/GPIO/: GPIO_Adapter.c
  group framework-Keyboard-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Keyboard/Interface/: Keyboard.h
  group framework-Keyboard-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Keyboard/Source/: Keyboard.c
  group framework-LED-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/LED/Interface/: LED.h
  group framework-LED-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/LED/Source/: LED.c
  group framework-Reset-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Reset/: Reset.c
  group framework-Common
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Common/: EmbeddedTypes.h
  group framework-MemManager-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/MemManager/Interface/: MemManager.h
  group framework-MemManager-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/MemManager/Source/: MemManager.c
  group framework-Messaging-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Messaging/Interface/: Messaging.h
  group framework-Messaging-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Messaging/Source/: Messaging.c
  group framework-Panic-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Panic/Interface/: Panic.h
  group framework-Panic-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Panic/Source/: Panic.c
  group framework-RNG-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/RNG/Interface/: RNG_Interface.h
  group framework-RNG-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/RNG/Source/: RNG.c
  group framework-NVM-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/NVM/Interface/: NVM_Interface.h
  group framework-NVM-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/NVM/Source/: NV_Flash.c NV_Flash.h NV_FsciCommands.c NV_FsciCommands.h
  group framework-SerialManager-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/SerialManager/Interface/: SerialManager.h
  group framework-SerialManager-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/SerialManager/Source/: SerialManager.c UART_Adapter.h UART_Adapter.c I2C_Adapter.h I2C_Adapter.c
  group framework-SerialManager-Source-SPI_Adapter
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/SerialManager/Source/SPI_Adapter/: SPI_Adapter.c SPI_Adapter.h
  group framework-TimersManager-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/TimersManager/Interface/: TimersManager.h
  group framework-TimersManager-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/TimersManager/Source/: TimersManager.c TMR_Adapter.h TMR_Adapter.c TimersManagerInternal.h
  group framework-ModuleInfo
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/ModuleInfo/: ModuleInfo.h ModuleInfo.c
  group framework-FunctionLib
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/FunctionLib/: FunctionLib.c FunctionLib.h
  group framework-Lists
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/Lists/: GenericList.c GenericList.h
  group framework-SecLib
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/SecLib/: SecLib.h SecLib.c
  group bluetooth-host-interface
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/host/interface/: att_callbacks.h att_errors.h att_interface.h att_params.h att_types.h ble_constants.h ble_general.h ble_host_tasks.h ble_sig_defines.h ble_utils.h gap_interface.h gap_types.h gatt_client_interface.h gatt_database.h gatt_db_app_interface.h gatt_db_dynamic.h gatt_interface.h gatt_server_interface.h gatt_types.h hci_interface.h hci_types.h l2ca_cb_interface.h l2ca_interface.h l2ca_types.h vendor_debug_commands.h
  group source-common
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/application/common/: ble_host_tasks.c ble_conn_manager.c ble_conn_manager.h ble_controller_task.c ApplMain.c ApplMain.h ble_init.c ble_init.h ieee11073.h ble_controller_task_config.h ble_host_task_config.h
  group bluetooth-host-config
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/host/config/: ble_config.h ble_globals.c
  group bluetooth-controller-interface
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/controller/interface/qn908xcdk/: _reg_ble_em_cs.h _reg_ble_em_ral.h _reg_ble_em_rx_desc.h _reg_ble_em_tx_buffer_cntl.h _reg_ble_em_tx_desc.h _reg_ble_em_wpb.h _reg_ble_em_wpv.h _reg_common_em_et.h co_bt.h co_hci.h co_list.h co_llcp.h compiler.h controller_config.c dbg_task.h em_buf.h em_map.h em_map_ble.h ke_msg.h ke_task.h llc.h llc_task.h lld_evt.h llm_task.h qn_ble_config.h qnip_config.h rwble_config.h rwip.h rwip_config.h rwip_task.h
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/controller/interface/: controller_interface.h
  group bluetooth-hci_transport-interface
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/hci_transport/interface/: hci_transport.h
  group bluetooth-hci_transport-source
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/hci_transport/source/: hcit_serial_interface.c
  group source-common-gatt_db-macros
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/application/common/gatt_db/macros/: gatt_alloc_x.h gatt_db_macros.h gatt_db_x_macros.h gatt_decl_x.h gatt_enum_x.h gatt_init_x.h gatt_size_x.h gatt_uuid_decl_x.h gatt_uuid_def_x.h
  group source-common-gatt_db
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/application/common/gatt_db/: gatt_database.c gatt_database_dynamic.c
  group bluetooth-profiles-battery
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/profiles/battery/: battery_service.c battery_interface.h
  group bluetooth-profiles-device_info
    ../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/profiles/device_info/: device_info_interface.h device_info_service.c
  group framework-MWSCoexistence-Interface
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/MWSCoexistence/Interface/: MWS.h
  group framework-MWSCoexistence-Source
    ../../../../../../../../../../../middleware/wireless/framework_5.6.3/MWSCoexistence/Source/: MWS.c
  group doc
    ../../: readme.txt
  group drivers
    ../../../../../../../../../../../devices/QN908XC/drivers/: fsl_common.h fsl_common.c fsl_rng.h fsl_rng.c fsl_flash.h fsl_flash.c fsl_usart.h fsl_usart.c fsl_gpio.h fsl_gpio.c fsl_wdt.c fsl_wdt.h fsl_rf.h fsl_rf.c fsl_ctimer.h fsl_ctimer.c fsl_clock.h fsl_clock.c fsl_calibration.h fsl_calibration.c fsl_flexcomm.h fsl_flexcomm.c fsl_rtc.h fsl_rtc.c fsl_reset.h fsl_reset.c fsl_power.h fsl_power.c fsl_syscon.h fsl_adc.h fsl_adc.c fsl_iocon.h fsl_inputmux.h fsl_inputmux.c fsl_inputmux_connections.h fsl_spi.c fsl_spi.h fsl_i2c.h fsl_i2c.c
  group utilities
    ../../../../../../../../../../../devices/QN908XC/utilities/: fsl_debug_console.c fsl_debug_console.h
  group mijia_ble_api
    ../../../../portable/: mible_api.c QN908x_api.c QN908x_evt.c
  group mijia_ble_common
    ../../../../../../libs/common/: ccm.c mible_beacon.c queue.c sha256_hkdf.c
  group mijia_ble_authen
    ../../../../../../libs/mible_app_authen/: mible_crypto.c mible_FSM.c mible_ll_callback.c mible_server.c
target mjia_profile_server_bm Release (ARM-ADS)
  device: QN9080C NXP
  pack: NXP.QN908x_DFP.1.1.4
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: private_profile_server_bm.out
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_QN908X, SDK_DEBUGCONSOLE=1, PRINTF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, CFG_BLE_PRJ=1, CPU_QN9080C
  c misc: --preinclude ../../../../../../../../../../../boards/qn908xcdk/wireless_examples/bluetooth/private_profile_server/bm/app_preinclude.h 
--library_interface=armcc 
--library_type=standardlib 
--diag_suppress=1,94 
--diag_suppress=66,1296,186 
--no_wchar
  c include: ../../../../../../../../../../../CMSIS/Include;../../../../../../../../../../../devices;../../../../../../../../../../../middleware/wireless/framework_5.6.3/OSAbstraction/Interface;..;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Flash/Internal;../../../../../../../../../../../middleware/wireless/framework_5.6.3/GPIO;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Keyboard/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/LED/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Common;../../../../../../../../../../../middleware/wireless/framework_5.6.3/MemManager/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Messaging/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Panic/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/RNG/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/NVM/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/NVM/Source;../../../../../../../../../../../middleware/wireless/framework_5.6.3/SerialManager/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/SerialManager/Source;../../../../../../../../../../../middleware/wireless/framework_5.6.3/SerialManager/Source/SPI_Adapter;../../../../../../../../../../../middleware/wireless/framework_5.6.3/TimersManager/Interface;../../../../../../../../../../../middleware/wireless/framework_5.6.3/TimersManager/Source;../../../../../../../../../../../middleware/wireless/framework_5.6.3/ModuleInfo;../../../../../../../../../../../middleware/wireless/framework_5.6.3/FunctionLib;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Lists;../../../../../../../../../../../middleware/wireless/framework_5.6.3/SecLib;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/host/interface;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/host/config;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/application/common;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/controller/interface;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/controller/interface/qn908xcdk;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/hci_transport/interface;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/application/common/gatt_db;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/application/common/gatt_db/macros;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/profiles/battery;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/profiles/device_info;../../../../../../../../../../../middleware/wireless/bluetooth_1.5.3/profiles/private_profile;../../../../../../../../../../../middleware/wireless/framework_5.6.3/MWSCoexistence/Interface;../..;../../../../../../../../../../../devices/QN908XC/drivers;../../../../../../../../../../../devices/QN908XC/utilities;../../../../../../../../../../../middleware/wireless/framework_5.6.3/Common/devices/QN908XC;../../../../../../../../../../../devices/QN908XC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x4000400 size 0xfc00
  scatter file: QN908XC_connectivity.scf
  link misc: as above
target lib (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: QN9080C NXP
  pack: NXP.QN908x_DFP.1.1.4
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: mijia_std_authen_keil_NXPQN980X.out (library)
  AfterMake: fromelf.exe --output "$L@L.bin" --bincombined "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: as above
  c include: as above
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x4000400 size 0xfc00
  scatter file: QN908XC_connectivity.scf
  link misc: as above
