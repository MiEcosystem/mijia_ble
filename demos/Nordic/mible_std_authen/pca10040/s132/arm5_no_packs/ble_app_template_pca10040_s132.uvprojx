# Keil uVision project ble_app_template_pca10040_s132.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: MI_LOG_ENABLED MI_ASSERT BLE_STACK_SUPPORT_REQD NRF_SD_BLE_API_VERSION=3 S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  c include: ..\..\..\config\ble_app_template_pca10040_s132;..\..\..\config;..\..\..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\..\..\external\segger_rtt;..\config;..\..\..\..\patch;..\..\..\..\portable;..\..\..\..\..\..\libs\common;..\..\..\..\..\..\libs\third_party;..\..\..\..\..\..\libs\secure_auth;..\..\..\..\..\..\libs\token_auth;..\..\..\..\..\..\libs\frdt;..\..\..\..\..\..\libs\mible_app_authen;..\..\..\..\mible_std_authen
  asm define: BLE_STACK_SUPPORT_REQD NRF_SD_BLE_API_VERSION=3 S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=3,-DS132,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DSWI_DISABLE0
  asm include: ..\..\..\config\ble_app_template_pca10040_s132;..\..\..\config;..\..\..\..\..\..\..\..\..\components;..\..\..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\..\..\components\ble\ble_dtm;..\..\..\..\..\..\..\..\..\components\ble\ble_racp;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ans_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_cscs;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_dfu;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_gls;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hids;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_hts;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ias;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_ias_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_lls;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_nus;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_nus_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\..\..\components\ble\ble_services\ble_tps;..\..\..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\..\..\components\ble\nrf_ble_qwr;..\..\..\..\..\..\..\..\..\components\ble\peer_manager;..\..\..\..\..\..\..\..\..\components\boards;..\..\..\..\..\..\..\..\..\components\drivers_nrf\adc;..\..\..\..\..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\..\components\drivers_nrf\comp;..\..\..\..\..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\..\components\drivers_nrf\i2s;..\..\..\..\..\..\..\..\..\components\drivers_nrf\lpcomp;..\..\..\..\..\..\..\..\..\components\drivers_nrf\pdm;..\..\..\..\..\..\..\..\..\components\drivers_nrf\power;..\..\..\..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\..\..\..\components\drivers_nrf\pwm;..\..\..\..\..\..\..\..\..\components\drivers_nrf\qdec;..\..\..\..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\..\..\..\..\components\drivers_nrf\rtc;..\..\..\..\..\..\..\..\..\components\drivers_nrf\saadc;..\..\..\..\..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\..\..\..\components\drivers_nrf\swi;..\..\..\..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\..\..\components\drivers_nrf\usbd;..\..\..\..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\..\components\libraries\crc16;..\..\..\..\..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\..\..\..\..\components\libraries\csense;..\..\..\..\..\..\..\..\..\components\libraries\csense_drv;..\..\..\..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\..\..\..\components\libraries\fds;..\..\..\..\..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\..\..\..\components\libraries\hardfault;..\..\..\..\..\..\..\..\..\components\libraries\hci;..\..\..\..\..\..\..\..\..\components\libraries\led_softblink;..\..\..\..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\..\..\..\components\libraries\low_power_pwm;..\..\..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\..\..\components\libraries\pwm;..\..\..\..\..\..\..\..\..\components\libraries\queue;..\..\..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\..\..\..\..\components\libraries\slip;..\..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\..\components\libraries\twi;..\..\..\..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\..\..\..\components\libraries\usbd;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\audio;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\generic;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\..\..\..\..\components\libraries\usbd\class\msc;..\..\..\..\..\..\..\..\..\components\libraries\usbd\config;..\..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\segger_rtt;..\config;..\..\..\..\..\..\libs\mible_app_authen
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002158 size 0xdea8
  group Application
    ../config/: sdk_config.h
    ../../../: main.c time.c
  group mijia_ble_api
    ../../../../portable/: mi_psm.c mible_api.c nRF5_api.c nRF5_evt.c
  group mijia_ble_common
    ../../../../../../libs/common/: ccm.c mible_beacon.c sha256_hkdf.c queue.c
  group mijia_std_authen
    ../../../../../../libs/mible_app_authen/: mijia_std_authen_keil1.0.lib
  group Board Definition
    ../../../../../../../../../components/boards/: boards.c
  group Board Support
    ../../../../../../../../../components/libraries/bsp/: bsp_btn_ble.c bsp_nfc.c bsp.c
  group nRF_patch
    ../../../../patch/: app_timer_patched.c nrf_drv_twi_patched.c
  group nRF_BLE
    ../../../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../../../../components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../../../../../../../../../components/libraries/fds/: fds.c
    ../../../../../../../../../components/libraries/fstorage/: fstorage.c
    ../../../../../../../../../components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../../../../../components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../../../../../../components/libraries/queue/: nrf_queue.c
  group nRF_Log
    ../../../../../../../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../../../../../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
software components: CMSIS:CORE 5.0.2, Device:Startup 8.15.0
