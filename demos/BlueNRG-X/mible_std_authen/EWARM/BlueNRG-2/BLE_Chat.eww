<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\BLE_Chat.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>BUILD_ALL</name>
      <member>
        <project>BLE_Chat</project>
        <configuration>Client</configuration>
      </member>
      <member>
        <project>BLE_Chat</project>
        <configuration>Server</configuration>
      </member>
      <member>
        <project>BLE_Chat</project>
        <configuration>Server_HigherApp_OTA</configuration>
      </member>
      <member>
        <project>BLE_Chat</project>
        <configuration>Server_LowerApp_OTA</configuration>
      </member>
      <member>
        <project>BLE_Chat</project>
        <configuration>Server_Use_OTA_ServiceManager</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


