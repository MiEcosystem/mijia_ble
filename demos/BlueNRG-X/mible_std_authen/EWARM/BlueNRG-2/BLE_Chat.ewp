# IAR project BLE_Chat.ewp, settings and files
configuration Client (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-2 ST BlueNRG-2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; CLIENT=1
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\Library\Bluetooth_LE\OTA\inc; ..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Chat_Client.hex
  ILINK.IlinkOutputFile: BlueNRG-1_BLE_Chat_Client.out
  ILINK.IlinkIcfFile: BlueNRG2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Server (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; SERVER=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libs\common; ..\..\..\..\..\libs\mible_app_authen; ..\..\..\portable; ..\..\inc; ..\..\..\..\..\..\..\..\Library\BlueNRG1_Periph_Driver\inc; ..\..\..\..\..\..\..\..\Library\Bluetooth_LE\library; ..\..\..\..\..\..\..\..\Library\Bluetooth_LE\inc; ..\..\..\..\..\..\..\..\Library\CMSIS\Include; ..\..\..\..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Include; ..\..\..\..\..\..\..\..\Library\CMSIS\Device\ST\BlueNRG1\Source; ..\..\..\..\..\..\..\..\Library\hal\inc; ..\..\..\..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\..\..\..\Library\SDK_Eval_BlueNRG1\inc; ..\..\..\..\..\..\..\..\Library\Bluetooth_LE\OTA\inc
  OBJCOPY.OOCOutputFile: BLE_Chat_Server.hex
  ILINK.IlinkOutputFile: BlueNRG-1_BLE_Chat_Server.out
configuration Server_LowerApp_OTA (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; SERVER=1; ST_OTA_LOWER_APPLICATION=1
  OBJCOPY.OOCOutputFile: BLE_Chat_Server_LowerApp_OTA.hex
  postbuild: ielftool.exe --bin --verbose "Server_LowerApp_OTA\Exe\BLE_Chat_Server_LowerApp_OTA.out"  "Server_LowerApp_OTA\Exe\BLE_Chat_Server_LowerApp_OTA.bin"
  ILINK.IlinkOutputFile: BLE_Chat_Server_LowerApp_OTA.out
  ILINK.IlinkConfigDefines: ST_OTA_LOWER_APPLICATION=1
configuration Server_HigherApp_OTA (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; SERVER=1; ST_OTA_HIGHER_APPLICATION=1
  OBJCOPY.OOCOutputFile: BLE_Chat_Server_HigherApp_OTA.hex
  postbuild: ielftool.exe --bin --verbose "Server_HigherApp_OTA\Exe\BLE_Chat_Server_HigherApp_OTA.out" "Server_HigherApp_OTA\Exe\BLE_Chat_Server_HigherApp_OTA.bin"
  ILINK.IlinkOutputFile: BLE_Chat_Server_HigherApp_OTA.out
  ILINK.IlinkConfigDefines: ST_OTA_HIGHER_APPLICATION=1
configuration Server_Use_OTA_ServiceManager (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BLUENRG2_DEVICE; HS_SPEED_XTAL=HS_SPEED_XTAL_32MHZ; LS_SOURCE=LS_SOURCE_EXTERNAL_32KHZ; SMPS_INDUCTOR=SMPS_INDUCTOR_10uH; SERVER=1; ST_USE_OTA_SERVICE_MANAGER_APPLICATION=1
  OBJCOPY.OOCOutputFile: BLE_Chat_Server_Use_OTA_ServiceManager.hex
  postbuild: ielftool.exe --bin --verbose "Server_Use_OTA_ServiceManager\Exe\BLE_Chat_Server_Use_OTA_ServiceManager.out"  "Server_Use_OTA_ServiceManager\Exe\BLE_Chat_Server_Use_OTA_ServiceManager.bin"
  ILINK.IlinkOutputFile: BLE_Chat_Server_Use_OTA_ServiceManager.out
  ILINK.IlinkConfigDefines: ST_USE_OTA_SERVICE_MANAGER_APPLICATION=1
  group HAL
    ../../../../../../../../Library/hal/src/: clock.c context_switch.s gp_timer.c osal.c
  group Library
    ../../../../../../../../Library/BlueNRG1_Periph_Driver/src/: BlueNRG1_adc.c BlueNRG1_dma.c BlueNRG1_flash.c BlueNRG1_gpio.c BlueNRG1_i2c.c BlueNRG1_mft.c BlueNRG1_pka.c BlueNRG1_radio.c BlueNRG1_rng.c BlueNRG1_rtc.c BlueNRG1_spi.c BlueNRG1_sysCtrl.c BlueNRG1_uart.c BlueNRG1_wdg.c misc.c
  group libs/common
    ../../../../../libs/common/: ccm.c ccm.h mible_beacon.c mible_beacon.h queue.c queue.h sha256_hkdf.c sha256_hkdf.h
  group libs/mible_app_authen
    ../../../../../libs/mible_app_authen/: mible_crypto.h mible_FSM.h mible_server.h mijia_std_authen_IAR_BLUENRG-1_1_1_2.a
  group Platform_Layers
    ../../../../../../../../Library/SDK_Eval_BlueNRG1/src/: SDK_EVAL_Button.c SDK_EVAL_Com.c SDK_EVAL_Config.c SDK_EVAL_Led.c
  group portable
    ../../../portable/: blueNRG_api.c blueNRG_port.c blueNRG_port.h mible_api.c mible_api.h mible_log.h mible_log_internal.h mible_port.h mible_type.h
  group Stack
    ../../../../../../../../Library/Bluetooth_LE/library/: libbluenrg1_stack.a
  group Startup
    ../../../../../../../../Library/CMSIS/Device/ST/BlueNRG1/Source/: system_bluenrg1.c
  group User
    ../../src/: BLE_Chat_main.c BlueNRG1_it.c gatt_db.c
