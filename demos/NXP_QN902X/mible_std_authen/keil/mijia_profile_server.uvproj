# Keil uVision project mijia_profile_server.uvproj, settings and files
target mijia_profile_server (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: QN9020 NXP
  cpu: IRAM(0x00008000-0x0000FFFF) IROM(0x00000000-0x00007FFF) CLOCK(16000000) CPUTYPE("Cortex-M0")
  output: mijia_profile_server
  AfterMake: fromelf --bin --output ./bin/mijia_profile_server.bin ./obj/mijia_profile_server.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: MI_LOG_ENABLED
  c misc: --C99
  c include: ..\..\..\..\..\src\fw;..\..\..\..\..\src\profiles;..\..\..\..\..\src\profiles\dis\diss;..\..\..\..\..\src\app;..\..\..\..\..\src\app\gap;..\..\..\..\..\src\app\gatt;..\..\..\..\..\src\app\smp;..\..\..\..\..\src\app\diss;..\..\..\..\..\src\cmsis;..\..\..\..\..\src\driver;..\..\..\..\..\src\lib;..\..\..\..\..\src\qnevb;..\src;..\..\..\..\..\src\app\mis;..\..\..\..\..\src\profiles\mis;..\..\..\..\..\src\profiles\mis\mis;..\..\portable;..\..\..\..\libs\mible_app_authen;..\..\..\..\libs\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  scatter file: ..\..\..\..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
  group startup
    ../../../../../src/startup/keil/: startup.s
  group main
    ../../../../../src/main/: app_main.c
  group usr
    ../src/: system.c usr_design.c
  group app
    ../../../../../src/app/: app_env.c app_sys.c app_task.c app_util.c
    ../../../../../src/app/gap/: app_gap.c app_gap_task.c
    ../../../../../src/app/gatt/: app_gatt.c app_gatt_task.c
    ../../../../../src/app/smp/: app_smp.c app_smp_task.c
    ../../../../../src/app/mis/: app_mis.c app_mis_task.c
  group profiles
    ../../../../../src/profiles/mis/mis/: mis.c mis_task.c
    ../../../../../src/profiles/: prf_utils.c
  group drivers
    ../../../../../src/driver/: adc.c analog.c bletime.c dma.c gpio.c i2c.c pwm.c rng.c rtc.c serialflash.c sleep.c spi.c syscon.c timer.c uart.c wdt.c
  group lib
    C:/nxp/QN902x_SDK_1.4.0/Projects/BLE/src/lib/keil/: qn9020b2_lib_peripheral_v40.lib qn9020b2_lib_peripheral_v42.lib qn9020b4_lib_peripheral_v40.lib qn9020b4_lib_peripheral_v42.lib
  group qnevb
    ../../../../../src/qnevb/: button.c led.c
  group retarget
    ../../../../../src/retarget/: retarget.c
  group mible_api
    ../../portable/: aes.c mible_api.c QN902x_api.c QN902x_evt.c
  group mible_common
    ../../../../libs/common/: ccm.c mible_beacon.c queue.c sha256_hkdf.c
  group mible_authen
    ../../../../libs/mible_app_authen/: mijia_std_authen_keil_QN902x_1_1_2.lib
target mijia_lib (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: QN9020 NXP
  cpu: as above
  output: mijia_std_authen_keil_QN902x_1_1_2 (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: MI_LOG_ENABLED
  c misc: --C99
  c include: ..\..\..\..\..\src\fw;..\..\..\..\..\src\profiles;..\..\..\..\..\src\profiles\dis\diss;..\..\..\..\..\src\app;..\..\..\..\..\src\app\gap;..\..\..\..\..\src\app\gatt;..\..\..\..\..\src\app\smp;..\..\..\..\..\src\app\diss;..\..\..\..\..\src\cmsis;..\..\..\..\..\src\driver;..\..\..\..\..\src\lib;..\..\..\..\..\src\qnevb;..\..\..\..\src;..\..\..\..\..\src\app\mis;..\..\..\..\..\src\profiles\mis;..\..\..\..\..\src\profiles\mis\mis;..\..\portable;..\..\..\..\libs\mible_app_authen;..\..\..\..\libs\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x8000 size 0x8000
  scatter file: ..\..\..\..\..\src\link\keil\qn9020_link.sct
  link misc: --no_autoat --remove
